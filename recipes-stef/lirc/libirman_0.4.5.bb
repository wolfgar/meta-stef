DESCRIPTION = "libirman is a library for accessing the IRMAN hardware from Linux and other Unix systems"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=0636e73ff0215e8d672dc4c32c317bb3"

inherit autotools 

SRC_URI = "http://downloads.sourceforge.net/lirc/libirman/0.4.5/libirman-0.4.5.tar.gz"
SRC_URI[md5sum] = "1a1a581212ee3143845ebf7f9c6e5471"
