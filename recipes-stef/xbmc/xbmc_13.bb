require xbmc.inc
SRCREV="142185faad7e34ee1aee70fcace1ee1a80cdd294"


PR = "${INC_PR}.0"

