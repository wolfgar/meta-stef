require ffmpeg.inc

PR = "${INC_PR}.1"
SRC_URI = "https://github.com/xbmc/FFmpeg/archive/2.4.2-Helix-alpha5.tar.gz"
S = "${WORKDIR}/FFmpeg-2.4.2-Helix-alpha5"
SRC_URI[md5sum] = "3aab0ff51262052e38f4fb98e8305869"
SRC_URI[sha256sum] = "a9ce796122edd5a06ac45722e02fef7d6583af7ab92b2461ada608d83191f8ec"


