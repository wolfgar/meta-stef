DEPENDS += "imx-vpu"
