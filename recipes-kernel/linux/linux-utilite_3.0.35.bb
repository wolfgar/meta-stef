
include linux-utilite.inc

# Current version is based on fsl BSP 4.1.0
SRCREV = "cb622c39b8b2f1d8cafbbffea16aadac0fd3a110"

COMPATIBLE_MACHINE = "(utilite)"
