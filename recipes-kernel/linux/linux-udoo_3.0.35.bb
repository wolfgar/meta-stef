
include linux-udoo.inc

# Current version is based on fsl BSP 4.1.0
SRCREV = "192842b1c7aee8c7dc24634819f4fd85cb596eb7"

COMPATIBLE_MACHINE = "(udoo)"
