#Remove dependency upon mesa to get rid of x11
RDEPENDS_libgl-mx6-dev =""

